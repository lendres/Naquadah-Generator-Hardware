File: Power Daughter Board/Power Daughter Board.sch (KiCad schematic (older format))
At the start: 31 parts, among them J1 Power Board Conn, J2 Jack-DC, SW1 MHPS2283, SW2 MHPS2283N, U1 MCP73833T

Commit message: Power board 2 switch V1
Parts:
- TP2: Name SW -> MODE
- TP5: Name MODE -> SW
Connections:
- net labels added: ONIND
- net labels removed: ON
Other:
- moved on the sheet: D1, D5, R1, R5
Changed lines of the file:
@@
 	1    0    0    -1
 $EndComp
-Text Label 8050 4500 0    50   ~ 0
+Text Label 8350 4500 2    50   ~ 0
 READY
-Text Label 8050 4700 0    50   ~ 0
+Text Label 8350 4700 2    50   ~ 0
 BATT+
-Text Label 8050 4600 0    50   ~ 0
-SWITCH
+Text Label 8350 4600 2    50   ~ 0
+MODE
 Wire Wire Line
 	8450 4800 8450 4900
@@
 L Li-ion_5A_Boost_1A_Charge_Protect:LED D1
 U 1 1 5EDBD7E3
-P 2550 4150
-F 0 "D1" H 2450 4250 50  0000 L CNN
-F 1 "GREEN" H 2450 4050 50  0000 L CNN
-F 2 "Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder" H 2550 4150 50  0001 C CNN
-F 3 "https://www.we-online.de/katalog/datasheet/150080VS75000.pdf" H 2550 4150 50  0001 C CNN
-F 4 "Green 570nm LED Indication - Discrete 2V 0805 (2012 Metric)" H 2550 4150 50  0001 C CNN "Description"
-F 5 "Digikey" H 2550 4150 50  0001 C CNN "Source"
-F 6 "732-4986-1-ND" H 2550 4150 50  0001 C CNN "Source Part No."
-F 7 "Würth Elektronik" H 2550 4150 50  0001 C CNN "Manufacturer Name"
-F 8 "150080VS75000" H 2550 4150 50  0001 C CNN "Manufacturer Part No."
-	1    2550 4150
+P 2550 4750
+F 0 "D1" H 2450 4850 50  0000 L CNN
+F 1 "GREEN" H 2450 4650 50  0000 L CNN
+F 2 "Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder" H 2550 4750 50  0001 C CNN
+F 3 "https://www.we-online.de/katalog/datasheet/150080VS75000.pdf" H 2550 4750 50  0001 C CNN
+F 4 "Green 570nm LED Indication - Discrete 2V 0805 (2012 Metric)" H 2550 4750 50  0001 C CNN "Description"
+F 5 "Digikey" H 2550 4750 50  0001 C CNN "Source"
+F 6 "732-4986-1-ND" H 2550 4750 50  0001 C CNN "Source Part No."
+F 7 "Würth Elektronik" H 2550 4750 50  0001 C CNN "Manufacturer Name"
+F 8 "150080VS75000" H 2550 4750 50  0001 C CNN "Manufacturer Part No."
+	1    2550 4750
 	0    -1   -1   0
 $EndComp
@@
 L Li-ion_5A_Boost_1A_Charge_Protect:R R1
 U 1 1 5EDBD7F9
-P 2550 4750
-F 0 "R1" V 2450 4650 59  0000 L CNN
-F 1 "1k" V 2650 4650 59  0000 L CNN
-F 2 "Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder" H 2550 4750 50  0001 C CNN
-F 3 "http://www.koaspeer.com/pdfs/RK73H.pdf" H 2550 4750 50  0001 C CNN
-F 4 "1 kOhms ±1% 0.25W, 1/4W Chip Resistor 1206 (3216 Metric) " H 2550 4750 50  0001 C CNN "Description"
-F 5 "Digikey" H 2550 4750 50  0001 C CNN "Source"
-F 6 "2019-RK73H2ATTD1001FCT-ND" H 2550 4750 50  0001 C CNN "Source Part No."
-F 7 "KOA Speer Electronics, Inc." H 2550 4750 50  0001 C CNN "Manufacturer Name"
-F 8 "RK73H2ATTD1001F" H 2550 4750 50  0001 C CNN "Manufacturer Part No."
-	1    2550 4750
+P 2550 4150
+F 0 "R1" V 2450 4050 59  0000 L CNN
+F 1 "1k" V 2650 4050 59  0000 L CNN
+F 2 "Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder" H 2550 4150 50  0001 C CNN
+F 3 "http://www.koaspeer.com/pdfs/RK73H.pdf" H 2550 4150 50  0001 C CNN
+F 4 "1 kOhms ±1% 0.25W, 1/4W Chip Resistor 1206 (3216 Metric) " H 2550 4150 50  0001 C CNN "Description"
+F 5 "Digikey" H 2550 4150 50  0001 C CNN "Source"
+F 6 "2019-RK73H2ATTD1001FCT-ND" H 2550 4150 50  0001 C CNN "Source Part No."
+F 7 "KOA Speer Electronics, Inc." H 2550 4150 50  0001 C CNN "Manufacturer Name"
+F 8 "RK73H2ATTD1001F" H 2550 4150 50  0001 C CNN "Manufacturer Part No."
+	1    2550 4150
 	1    0    0    -1
 $EndComp
@@
 F 2 "Frequently_Used:Pad_2.5-2.5" H 8150 4300 50  0001 C CNN
 F 3 "None" H 8150 4300 50  0001 C CNN
-F 4 "SW" H 7950 4500 50  0000 C CNN "Name"
+F 4 "MODE" H 7950 4500 50  0000 C CNN "Name"
 F 5 "Test point" H 7950 4300 50  0001 C CNN "Description"
 F 6 "None" H 7950 4300 50  0001 C CNN "Source"
@@
 L Li-ion_5A_Boost_1A_Charge_Protect:LED D5
 U 1 1 5ED9610C
-P 1200 4150
-F 0 "D5" H 1100 4250 50  0000 L CNN
-F 1 "RED" H 1100 4050 50  0000 L CNN
-F 2 "Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder" H 1200 4150 50  0001 C CNN
-F 3 "https://www.we-online.de/katalog/datasheet/150080RS75000.pdf" H 1200 4150 50  0001 C CNN
-F 4 "Red 625nm LED Indication - Discrete 2V 0805 (2012 Metric)" H 1200 4150 50  0001 C CNN "Description"
-F 5 "Digikey" H 1200 4150 50  0001 C CNN "Source"
-F 6 "732-4984-1-ND" H 1200 4150 50  0001 C CNN "Source Part No."
-F 7 "Würth Elektronik" H 1200 4150 50  0001 C CNN "Manufacturer Name"
-F 8 "150080RS75000" H 1200 4150 50  0001 C CNN "Manufacturer Part No."
-	1    1200 4150
+P 1200 4750
+F 0 "D5" H 1100 4850 50  0000 L CNN
+F 1 "RED" H 1100 4650 50  0000 L CNN
+F 2 "Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder" H 1200 4750 50  0001 C CNN
+F 3 "https://www.we-online.de/katalog/datasheet/150080RS75000.pdf" H 1200 4750 50  0001 C CNN
+F 4 "Red 625nm LED Indication - Discrete 2V 0805 (2012 Metric)" H 1200 4750 50  0001 C CNN "Description"
+F 5 "Digikey" H 1200 4750 50  0001 C CNN "Source"
+F 6 "732-4984-1-ND" H 1200 4750 50  0001 C CNN "Source Part No."
+F 7 "Würth Elektronik" H 1200 4750 50  0001 C CNN "Manufacturer Name"
+F 8 "150080RS75000" H 1200 4750 50  0001 C CNN "Manufacturer Part No."
+	1    1200 4750
 	0    -1   -1   0
 $EndComp
@@
 L Li-ion_5A_Boost_1A_Charge_Protect:R R5
 U 1 1 5ED96117
-P 1200 4750
-F 0 "R5" V 1100 4650 59  0000 L CNN
-F 1 "1k" V 1300 4650 59  0000 L CNN
-F 2 "Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder" H 1200 4750 50  0001 C CNN
-F 3 "http://www.koaspeer.com/pdfs/RK73H.pdf" H 1200 4750 50  0001 C CNN
-F 4 "1 kOhms ±1% 0.25W, 1/4W Chip Resistor 1206 (3216 Metric) " H 1200 4750 50  0001 C CNN "Description"
-F 5 "Digikey" H 1200 4750 50  0001 C CNN "Source"
-F 6 "2019-RK73H2ATTD1001FCT-ND" H 1200 4750 50  0001 C CNN "Source Part No."
-F 7 "KOA Speer Electronics, Inc." H 1200 4750 50  0001 C CNN "Manufacturer Name"
-F 8 "RK73H2ATTD1001F" H 1200 4750 50  0001 C CNN "Manufacturer Part No."
-	1    1200 4750
+P 1200 4150
+F 0 "R5" V 1100 4050 59  0000 L CNN
+F 1 "1k" V 1300 4050 59  0000 L CNN
+F 2 "Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder" H 1200 4150 50  0001 C CNN
+F 3 "http://www.koaspeer.com/pdfs/RK73H.pdf" H 1200 4150 50  0001 C CNN
+F 4 "1 kOhms ±1% 0.25W, 1/4W Chip Resistor 1206 (3216 Metric) " H 1200 4150 50  0001 C CNN "Description"
+F 5 "Digikey" H 1200 4150 50  0001 C CNN "Source"
+F 6 "2019-RK73H2ATTD1001FCT-ND" H 1200 4150 50  0001 C CNN "Source Part No."
+F 7 "KOA Speer Electronics, Inc." H 1200 4150 50  0001 C CNN "Manufacturer Name"
+F 8 "RK73H2ATTD1001F" H 1200 4150 50  0001 C CNN "Manufacturer Part No."
+	1    1200 4150
 	1    0    0    -1
 $EndComp
@@
 $EndComp
 Text Label 2550 4550 1    50   ~ 0
-ON
+ONIND
 Text Label 1200 4550 1    50   ~ 0
 RDYIND
@@
 F 2 "Frequently_Used:Pad_2.5-2.5" H 7650 4300 50  0001 C CNN
 F 3 "None" H 7650 4300 50  0001 C CNN
-F 4 "MODE" H 7450 4500 50  0000 C CNN "Name"
+F 4 "SW" H 7450 4500 50  0000 C CNN "Name"
 F 5 "Test point" H 7450 4300 50  0001 C CNN "Description"
 F 6 "None" H 7450 4300 50  0001 C CNN "Source"
@@
 NoConn ~ 5900 4800
 Text Label 8350 4400 2    50   ~ 0
-MODE
+SWITCH
 $Comp
 L Naquadah_Generator:GND #PWR0103

Commit message: Updates
Parts:
- H1, H2, H3, H4: footprint Naquadah Generator:MountingHole_2.2mm_M2 -> Naquadah_Generator:MountingHole_2.7mm_M2.5
- TP1: Name RDY -> READY
- TP3: Name B+ -> BATT+
- WA1: footprint Naquadah Generator:Wire_Assembly_Four -> Naquadah_Generator:Wire_Assembly_Four
Changed lines of the file:
@@
 F 2 "Frequently_Used:Pad_2.5-2.5" H 7900 4300 50  0001 C CNN
 F 3 "None" H 7900 4300 50  0001 C CNN
-F 4 "RDY" H 7700 4500 50  0000 C CNN "Name"
+F 4 "READY" H 7700 4500 50  0000 C CNN "Name"
 F 5 "Test point" H 7700 4300 50  0001 C CNN "Description"
 F 6 "None" H 7700 4300 50  0001 C CNN "Source"
@@
 F 2 "Frequently_Used:Pad_2.5-2.5" H 7900 4900 50  0001 C CNN
 F 3 "None" H 7900 4900 50  0001 C CNN
-F 4 "B+" H 7700 5100 50  0000 C CNN "Name"
+F 4 "BATT+" H 7700 5100 50  0000 C CNN "Name"
 F 5 "Test point" H 7700 4900 50  0001 C CNN "Description"
 F 6 "None" H 7700 4900 50  0001 C CNN "Source"
@@
 F 0 "WA1" H 4578 6946 50  0000 L CNN
 F 1 "WireAssembly" H 4578 6855 50  0000 L CNN
-F 2 "Naquadah Generator:Wire_Assembly_Four" H 4200 7000 50  0001 C CNN
+F 2 "Naquadah_Generator:Wire_Assembly_Four" H 4200 7000 50  0001 C CNN
 F 3 "http://www.jst-mfg.com/product/pdf/eng/eSR.pdf" H 4200 7000 50  0001 C CNN
 F 4 "6 Position Cable Assembly Rectangular Socket to Socket, Reversed 1.00' (304.80mm)" H 4200 6900 50  0001 C CNN "Description"
@@
 F 0 "H1" H 2100 6796 50  0000 L CNN
 F 1 "MountingHole" H 2100 6705 50  0000 L CNN
-F 2 "Naquadah Generator:MountingHole_2.2mm_M2" H 2000 6750 50  0001 C CNN
+F 2 "Naquadah_Generator:MountingHole_2.7mm_M2.5" H 2000 6750 50  0001 C CNN
 F 3 "None" H 2000 6750 50  0001 C CNN
 F 4 "None" H 2005 6625 50  0001 C CNN "Source"
@@
 F 0 "H2" H 2100 7046 50  0000 L CNN
 F 1 "MountingHole" H 2100 6955 50  0000 L CNN
-F 2 "Naquadah Generator:MountingHole_2.2mm_M2" H 2000 7000 50  0001 C CNN
+F 2 "Naquadah_Generator:MountingHole_2.7mm_M2.5" H 2000 7000 50  0001 C CNN
 F 3 "None" H 2000 7000 50  0001 C CNN
 F 4 "None" H 2005 6875 50  0001 C CNN "Source"
@@
 F 0 "H3" H 3050 6796 50  0000 L CNN
 F 1 "MountingHole" H 3050 6705 50  0000 L CNN
-F 2 "Naquadah Generator:MountingHole_2.2mm_M2" H 2950 6750 50  0001 C CNN
+F 2 "Naquadah_Generator:MountingHole_2.7mm_M2.5" H 2950 6750 50  0001 C CNN
 F 3 "None" H 2950 6750 50  0001 C CNN
 F 4 "None" H 2955 6625 50  0001 C CNN "Source"
@@
 F 0 "H4" H 3050 7046 50  0000 L CNN
 F 1 "MountingHole" H 3050 6955 50  0000 L CNN
-F 2 "Naquadah Generator:MountingHole_2.2mm_M2" H 2950 7000 50  0001 C CNN
+F 2 "Naquadah_Generator:MountingHole_2.7mm_M2.5" H 2950 7000 50  0001 C CNN
 F 3 "None" H 2950 7000 50  0001 C CNN
 F 4 "None" H 2955 6875 50  0001 C CNN "Source"
@@
 Wire Wire Line
 	7400 4400 7450 4400
+Wire Wire Line
+	7450 4300 7450 4400
+Connection ~ 7450 4400
+Wire Wire Line
+	7450 4400 8350 4400
+Wire Wire Line
+	5250 4900 5400 4900
+Text Label 6200 5050 2    50   ~ 0
+MODE
+Wire Wire Line
+	5900 5050 6200 5050
+Text Notes 5250 5400 0    79   ~ 16
+Mode Button
+$Comp
+L Naquadah_Generator:MHPS2283 SW2
+U 1 1 5EE03F4A
+P 5650 4900
+F 0 "SW2" H 5650 5325 50  0000 C CNN
+F 1 "MHPS2283N" H 5650 5234 50  0000 C CNN
+F 2 "Naquadah_Generator:MHPS2283" H 5150 4450 50  0001 L CNN
+F 3 "https://media.digikey.com/pdf/Data%20Sheets/APEM%20Components%20PDFs/MHPS_Series.pdf" H 5950 5100 50  0001 L CNN
+F 4 "APEM - MHPS2283 - Pushbutton Switch,STRAIGHT,DPDT,PC TAIL Terminal,PCB Hole Count:6" H 5150 4350 50  0001 L CNN "Description"
+F 5 "Digikey" H 5650 4900 50  0001 C CNN "Source"
+F 6 "679-4052-ND" H 5650 4900 50  0001 C CNN "Source Part No."
+F 7 "Apem" H 5650 4900 50  0001 C CNN "Manufacturer Name"
+F 8 "MHPS2283N" H 5150 4150 50  0001 L CNN "Manufacturer Part No."
+	1    5650 4900
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	5400 4850 5400 4900
+Connection ~ 5400 4900
+Wire Wire Line
+	5400 4900 5400 4950
+Wire Wire Line
+	5900 5000 5900 5050
+Connection ~ 5900 5050
+Wire Wire Line
+	5900 5050 5900 5100
+NoConn ~ 5900 4700
+NoConn ~ 5900 4800
+Text Label 8350 4400 2    50   ~ 0
+SWITCH
+$Comp
+L Naquadah_Generator:GND #PWR0103
+U 1 1 5EE06B20
+P 5250 5000
+F 0 "#PWR0103" H 5250 4750 50  0001 C CNN
+F 1 "GND" H 5255 4827 50  0000 C CNN
+F 2 "" H 5250 5000 50  0001 C CNN
+F 3 "" H 5250 5000 50  0001 C CNN
+	1    5250 5000
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	5250 4900 5250 5000
 $Comp
 L Frequently_Used:TestPoint TP5
@@
 	1    0    0    -1
 $EndComp
-Wire Wire Line
-	7450 4300 7450 4400
-Connection ~ 7450 4400
-Wire Wire Line
-	7450 4400 8350 4400
-Wire Wire Line
-	5250 4900 5400 4900
-Text Label 6200 5050 2    50   ~ 0
-MODE
-Wire Wire Line
-	5900 5050 6200 5050
-Text Notes 5250 5400 0    79   ~ 16
-Mode Button
-$Comp
-L Naquadah_Generator:MHPS2283 SW2
-U 1 1 5EE03F4A
-P 5650 4900
-F 0 "SW2" H 5650 5325 50  0000 C CNN
-F 1 "MHPS2283N" H 5650 5234 50  0000 C CNN
-F 2 "Naquadah_Generator:MHPS2283" H 5150 4450 50  0001 L CNN
-F 3 "https://media.digikey.com/pdf/Data%20Sheets/APEM%20Components%20PDFs/MHPS_Series.pdf" H 5950 5100 50  0001 L CNN
-F 4 "APEM - MHPS2283 - Pushbutton Switch,STRAIGHT,DPDT,PC TAIL Terminal,PCB Hole Count:6" H 5150 4350 50  0001 L CNN "Description"
-F 5 "Digikey" H 5650 4900 50  0001 C CNN "Source"
-F 6 "679-4052-ND" H 5650 4900 50  0001 C CNN "Source Part No."
-F 7 "Apem" H 5650 4900 50  0001 C CNN "Manufacturer Name"
-F 8 "MHPS2283N" H 5150 4150 50  0001 L CNN "Manufacturer Part No."
-	1    5650 4900
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	5400 4850 5400 4900
-Connection ~ 5400 4900
-Wire Wire Line
-	5400 4900 5400 4950
-Wire Wire Line
-	5900 5000 5900 5050
-Connection ~ 5900 5050
-Wire Wire Line
-	5900 5050 5900 5100
-NoConn ~ 5900 4700
-NoConn ~ 5900 4800
-Text Label 8350 4400 2    50   ~ 0
-SWITCH
-$Comp
-L Naquadah_Generator:GND #PWR0103
-U 1 1 5EE06B20
-P 5250 5000
-F 0 "#PWR0103" H 5250 4750 50  0001 C CNN
-F 1 "GND" H 5255 4827 50  0000 C CNN
-F 2 "" H 5250 5000 50  0001 C CNN
-F 3 "" H 5250 5000 50  0001 C CNN
-	1    5250 5000
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	5250 4900 5250 5000
 $EndSCHEMATC

Commit message: Move libraries and added configuration path.
Moved Li-Ion library to common KiCad library.  Added variables to configuration paths to reference my KiCad libraries.  Moved all 3D components to my common library.
Parts:
- C1, C2: footprint Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder -> Li-ion:0805_2012Metric_HandSolder; symbol Li-ion_5A_Boost_1A_Charge_Protect:C -> Li-ion_LE:C
- D1, D2, D3, D4, D5: footprint Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder -> Li-ion:LED_0805_2012Metric_HandSolder; symbol Li-ion_5A_Boost_1A_Charge_Protect:LED -> Li-ion_LE:LED
- R1, R2, R3, R4, R5, R6, R7, R8: footprint Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder -> Li-ion:0805_2012Metric_HandSolder; symbol Li-ion_5A_Boost_1A_Charge_Protect:R -> Li-ion_LE:R
- TH1: footprint Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder -> Li-ion:0805_2012Metric_HandSolder; symbol Li-ion_5A_Boost_1A_Charge_Protect:Thermistor_NTC -> Li-ion_LE:Thermistor_NTC
- TP1, TP2, TP3, TP4, TP5: footprint Frequently_Used:Pad_2.5-2.5 -> FrequentlyUsed:Pad_2.5-2.5; symbol Frequently_Used:TestPoint -> Frequently_Used_LE:TestPoint
- U1: footprint Li-ion 5A Boost 1A Charge Protect:MCP73833 -> Li-ion:MCP73833; symbol Li-ion_5A_Boost_1A_Charge_Protect:MCP73833T -> Li-ion_LE:MCP73833T

Commit message: Audio update
Parts:
- C1, C2: symbol Li-ion_LE:C -> Li_Ion_LE:C
- D1, D2, D3, D4, D5: symbol Li-ion_LE:LED -> Li_Ion_LE:LED
- R1, R2, R3, R4, R5, R6, R7, R8: symbol Li-ion_LE:R -> Li_Ion_LE:R
- TH1: symbol Li-ion_LE:Thermistor_NTC -> Li_Ion_LE:Thermistor_NTC
- TP1, TP2, TP3, TP4, TP5: footprint FrequentlyUsed:Pad_2.5-2.5 -> Frequently_Used_LE:Pad_2.5-2.5
- U1: symbol Li-ion_LE:MCP73833T -> Li_Ion_LE:MCP73833T
Changed lines of the file:
@@
 Charge
 $Comp
-L Li-ion_LE:MCP73833T U1
+L Li_Ion_LE:MCP73833T U1
 U 1 1 5EB6C38E
 P 5550 1950
@@
 PROG
 $Comp
-L Li-ion_LE:LED D3
+L Li_Ion_LE:LED D3
 U 1 1 5EBA8419
 P 3600 1900
@@
 $EndComp
 $Comp
-L Li-ion_LE:LED D4
+L Li_Ion_LE:LED D4
 U 1 1 5EBA883B
 P 3950 1900
@@
 $EndComp
 $Comp
-L Li-ion_LE:R R4
+L Li_Ion_LE:R R4
 U 1 1 5EBD0C80
 P 4600 2050
@@
 	3250 2350 3250 2050
 $Comp
-L Li-ion_LE:R R3
+L Li_Ion_LE:R R3
 U 1 1 5EBEA227
 P 4250 2200
@@
 $EndComp
 $Comp
-L Li-ion_LE:R R2
+L Li_Ion_LE:R R2
 U 1 1 5EBF1B19
 P 3900 2350
@@
 	6000 1750 6050 1750
 $Comp
-L Li-ion_LE:R R6
+L Li_Ion_LE:R R6
 U 1 1 5EB9EAAB
 P 6600 2050
@@
 	3600 2200 4100 2200
 $Comp
-L Li-ion_LE:C C2
+L Li_Ion_LE:C C2
 U 1 1 5EB4A5BF
 P 7700 2050
@@
 $EndComp
 $Comp
-L Li-ion_LE:C C1
+L Li_Ion_LE:C C1
 U 1 1 5EB4C1AB
 P 2850 2050
@@
 	2850 1750 2850 1900
 $Comp
-L Li-ion_LE:GND #PWR02
+L Li_Ion_LE:GND #PWR02
 U 1 1 5EB673E3
 P 6950 2650
@@
 	6950 2600 7300 2600
 $Comp
-L Li-ion_LE:GND #PWR01
+L Li_Ion_LE:GND #PWR01
 U 1 1 5EB6C4AE
 P 2850 2250
@@
 	7700 1750 8150 1750
 $Comp
-L Li-ion_LE:Thermistor_NTC TH1
+L Li_Ion_LE:Thermistor_NTC TH1
 U 1 1 5EBC49A8
 P 7300 2400
@@
 $EndComp
 $Comp
-L Li-ion_LE:R R8
+L Li_Ion_LE:R R8
 U 1 1 5EB60D47
 P 6400 2400
@@
 $EndComp
 $Comp
-L Li-ion_LE:R R7
+L Li_Ion_LE:R R7
 U 1 1 5EBB9C41
 P 6850 2400
@@
 Charging Connector
 $Comp
-L Li-ion_LE:LED D2
+L Li_Ion_LE:LED D2
 U 1 1 5EBA65E2
 P 3250 1900
@@
 SWITCH
 $Comp
-L Li-ion_LE:LED D1
+L Li_Ion_LE:LED D1
 U 1 1 5EDBD7E3
 P 2550 4750
@@
 	2550 4600 2550 4300
 $Comp
-L Li-ion_LE:R R1
+L Li_Ion_LE:R R1
 U 1 1 5EDBD7F9
 P 2550 4150
@@
 F 0 "TP1" H 7700 4600 50  0000 C CNN
 F 1 "TestPoint" H 7600 4050 50  0001 L CNN
-F 2 "FrequentlyUsed:Pad_2.5-2.5" H 7900 4300 50  0001 C CNN
+F 2 "Frequently_Used_LE:Pad_2.5-2.5" H 7900 4300 50  0001 C CNN
 F 3 "None" H 7900 4300 50  0001 C CNN
 F 4 "READY" H 7700 4500 50  0000 C CNN "Name"
@@
 F 0 "TP2" H 7950 4600 50  0000 C CNN
 F 1 "TestPoint" H 7850 4050 50  0001 L CNN
-F 2 "FrequentlyUsed:Pad_2.5-2.5" H 8150 4300 50  0001 C CNN
+F 2 "Frequently_Used_LE:Pad_2.5-2.5" H 8150 4300 50  0001 C CNN
 F 3 "None" H 8150 4300 50  0001 C CNN
 F 4 "MODE" H 7950 4500 50  0000 C CNN "Name"
@@
 F 0 "TP3" H 7700 5200 50  0000 C CNN
 F 1 "TestPoint" H 7600 4650 50  0001 L CNN
-F 2 "FrequentlyUsed:Pad_2.5-2.5" H 7900 4900 50  0001 C CNN
+F 2 "Frequently_Used_LE:Pad_2.5-2.5" H 7900 4900 50  0001 C CNN
 F 3 "None" H 7900 4900 50  0001 C CNN
 F 4 "BATT+" H 7700 5100 50  0000 C CNN "Name"
@@
 F 0 "TP4" H 7950 5200 50  0000 C CNN
 F 1 "TestPoint" H 7850 4650 50  0001 L CNN
-F 2 "FrequentlyUsed:Pad_2.5-2.5" H 8150 4900 50  0001 C CNN
+F 2 "Frequently_Used_LE:Pad_2.5-2.5" H 8150 4900 50  0001 C CNN
 F 3 "None" H 8150 4900 50  0001 C CNN
 F 4 "GND" H 7950 5100 50  0000 C CNN "Name"
@@
 	7950 4800 8450 4800
 $Comp
-L Li-ion_LE:LED D5
+L Li_Ion_LE:LED D5
 U 1 1 5ED9610C
 P 1200 4750
@@
 	1200 4600 1200 4300
 $Comp
-L Li-ion_LE:R R5
+L Li_Ion_LE:R R5
 U 1 1 5ED96117
 P 1200 4150
@@
 F 0 "TP5" H 7450 4600 50  0000 C CNN
 F 1 "TestPoint" H 7350 4050 50  0001 L CNN
-F 2 "FrequentlyUsed:Pad_2.5-2.5" H 7650 4300 50  0001 C CNN
+F 2 "Frequently_Used_LE:Pad_2.5-2.5" H 7650 4300 50  0001 C CNN
 F 3 "None" H 7650 4300 50  0001 C CNN
 F 4 "SW" H 7450 4500 50  0000 C CNN "Name"

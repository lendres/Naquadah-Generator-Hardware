File: Naquadah Generator Main/Naquadah Generator Main.sch (KiCad schematic (older format))
At the start: 15 parts, among them SW1 RESET, U1 ATmega32U4-AU, Y1 16MHz

Commit message: Audio update
Parts:
- C1, C2, C3, C4, C5, C6, C7: footprint FrequentlyUsed:0805_2012Metric_HandSolder -> Frequently_Used_LE:0805_2012Metric_HandSolder
- D23, D24: footprint FrequentlyUsed:LED_0805_2012Metric_HandSolder -> Frequently_Used_LE:LED_0805_2012Metric_HandSolder
- R1: footprint FrequentlyUsed:0805_2012Metric_HandSolder -> Frequently_Used_LE:0805_2012Metric_HandSolder; Description (none) -> 10 kOhms ±1% 0.25W, 1/4W Chip Resistor 0805 (2012 Metric); Manufacturer Name (none) -> KOA Speer Electronics, Inc.; Manufacturer Part No. (none) -> RK73H2ATTD1002F; Source (none) -> Digikey; Source Part No. (none) -> 2019-RK73H2ATTD1002FCT-ND
- R4, R9: footprint FrequentlyUsed:0805_2012Metric_HandSolder -> Frequently_Used_LE:0805_2012Metric_HandSolder; Description (none) -> 1 kOhms ±1% 0.25W, 1/4W Chip Resistor 1206 (3216 Metric); Manufacturer Name (none) -> KOA Speer Electronics, Inc.; Manufacturer Part No. (none) -> RK73H2ATTD1001F; Source (none) -> Digikey; Source Part No. (none) -> 2019-RK73H2ATTD1001FCT-ND
Connections:
- net labels added: DGND
- net labels removed: GNDD
- wire segments 103 -> 99
- no-connect marks 6 -> 2
Other:
- note added: "Crystal"
- note added: "Decoupling"
- note added: "LEDs"
- note added: "Reset Button"
- moved on the sheet: C1, C2, C3, C4, C5, C6, C7, D23, D24, R1, R4, R9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

Commit message: Audio updates, switching to separate USB schematic
Audio updates, switching to separate USB schematic
Parts:
- U1: Digikey Part No. (none) -> ATMEGA32U4-AU-ND
Connections:
- wire segments 99 -> 111
- no-connect marks 2 -> 7
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 1 15
+Sheet 1 16
 Title ""
 Date ""
@@
 	7050 3900 6550 3900
 Wire Wire Line
-	4750 2250 5250 2250
+	4750 2550 5250 2550
 Wire Wire Line
 	6550 2700 7050 2700
@@
 	6550 3000 7050 3000
 Wire Wire Line
-	4500 4000 4500 4100
+	4500 4050 4500 4150
 $Sheet
-S 2750 6800 500  400
+S 2650 6800 500  400
 U 5ED17BA0
 F0 "Shift Registers" 50
 F1 "Shift Registers.sch" 50
-F2 "SRLATCH" I L 2750 6900 50
-F3 "SRDATA" I L 2750 7100 50
-F4 "SRCLK" I L 2750 7000 50
+F2 "SRLATCH" I L 2650 6900 50
+F3 "SRDATA" I L 2650 7100 50
+F4 "SRCLK" I L 2650 7000 50
 $EndSheet
 Wire Wire Line
-	2750 6900 2350 6900
-Text Label 2350 6900 0    50   ~ 0
+	2650 6900 2250 6900
+Text Label 2250 6900 0    50   ~ 0
 SRLATCH
 Wire Wire Line
-	2750 7000 2350 7000
-Wire Wire Line
-	2750 7100 2350 7100
-Text Label 2350 7000 0    50   ~ 0
+	2650 7000 2250 7000
+Wire Wire Line
+	2650 7100 2250 7100
+Text Label 2250 7000 0    50   ~ 0
 SRCLK
 Wire Wire Line
-	5250 4000 4500 4000
-Wire Wire Line
-	5250 2150 4500 2150
-Wire Wire Line
-	4500 2150 4500 2250
+	5250 4050 5150 4050
+Wire Wire Line
+	5250 2450 4500 2450
+Wire Wire Line
+	4500 2450 4500 2550
 $Comp
 L Frequently_Used_LE:DGND #PWR016
 U 1 1 5EDBAB65
-P 4500 2250
-F 0 "#PWR016" H 4500 2000 50  0001 C CNN
-F 1 "DGND" H 4500 2100 50  0000 C CNN
-F 2 "" H 4500 2250 50  0001 C CNN
-F 3 "" H 4500 2250 50  0001 C CNN
-	1    4500 2250
-	1    0    0    -1
-$EndComp
-Text Label 4750 2250 0    50   ~ 0
+P 4500 2550
+F 0 "#PWR016" H 4500 2300 50  0001 C CNN
+F 1 "DGND" H 4500 2400 50  0000 C CNN
+F 2 "" H 4500 2550 50  0001 C CNN
+F 3 "" H 4500 2550 50  0001 C CNN
+	1    4500 2550
+	1    0    0    -1
+$EndComp
+Text Label 4750 2550 0    50   ~ 0
 UCAP
 $Comp
@@
 	2350 3350 2450 3350
 Wire Wire Line
-	4750 2700 5250 2700
-Text Label 4750 2700 0    50   ~ 0
+	4750 2950 5250 2950
+Text Label 4750 2950 0    50   ~ 0
 AREF
 Wire Wire Line
-	4750 1900 5250 1900
-Text Label 4750 1900 0    50   ~ 0
+	4750 2250 5250 2250
+Text Label 4750 2250 0    50   ~ 0
 D-
 Wire Wire Line
-	4750 1800 5250 1800
-Text Label 4750 1800 0    50   ~ 0
+	4750 2150 5250 2150
+Text Label 4750 2150 0    50   ~ 0
 D+
 Wire Wire Line
-	5250 1500 4500 1500
-Wire Wire Line
-	4500 1500 4500 1400
+	5250 1850 4500 1850
+Wire Wire Line
+	4500 1850 4500 1750
 Wire Wire Line
 	6550 2400 7050 2400
@@
 MODESEL
 Wire Wire Line
-	5250 1600 4500 1600
-Wire Wire Line
-	4500 1600 4500 1500
-Connection ~ 4500 1500
+	5250 1950 4500 1950
+Wire Wire Line
+	4500 1950 4500 1850
+Connection ~ 4500 1850
 $Comp
 L Frequently_Used_LE:VBUS #PWR015
 U 1 1 5EE32C9A
-P 4500 1400
-F 0 "#PWR015" H 4500 1250 50  0001 C CNN
-F 1 "VBUS" H 4500 1550 50  0000 C CNN
-F 2 "" H 4500 1400 50  0001 C CNN
-F 3 "" H 4500 1400 50  0001 C CNN
-	1    4500 1400
+P 4500 1750
+F 0 "#PWR015" H 4500 1600 50  0001 C CNN
+F 1 "VBUS" H 4500 1900 50  0000 C CNN
+F 2 "" H 4500 1750 50  0001 C CNN
+F 3 "" H 4500 1750 50  0001 C CNN
+	1    4500 1750
 	1    0    0    -1
 $EndComp
@@
 AREF
 Wire Wire Line
-	4750 2500 5250 2500
-Text Label 4750 2500 0    50   ~ 0
+	4750 2750 5250 2750
+Text Label 4750 2750 0    50   ~ 0
 nRESET
 Wire Wire Line
@@
 	4750 3250 5250 3250
 Wire Wire Line
-	4750 3550 5250 3550
+	4750 3350 5250 3350
 Wire Wire Line
 	2350 3500 2150 3500
@@
 Text Notes 5500 4600 0    79   ~ 16
 ATmega34U4
-Text Notes 2700 7550 0    79   ~ 16
+Text Notes 2600 7550 0    79   ~ 16
 Lights
 Wire Wire Line
@@
 Text Notes 1200 7500 0    79   ~ 16
 Power
-Text Label 2350 7100 0    50   ~ 0
+Text Label 2250 7100 0    50   ~ 0
 SRDATA
 Text Label 5700 6400 0    50   ~ 0
@@
 F 7 "ATmega Microcontroller IC 8-Bit 16MHz 32KB (16K x 16) FLASH 44-TQFP (10x10)" H 5900 2600 50  0001 C CNN "Description"
 F 8 "Digikey" H 5900 2600 50  0001 C CNN "Source"
+F 9 "ATMEGA32U4-AU-ND" H 5900 2600 50  0001 C CNN "Digikey Part No."
 	1    5900 2600
 	1    0    0    -1
@@
 TX
 $Sheet
-S 1200 6900 550  300
+S 1150 6800 550  400
 U 5EA6751D
 F0 "Power" 50
 F1 "Power.sch" 50
-F2 "READY" I L 1200 7000 50
-F3 "MODE" I L 1200 7100 50
+F2 "READY" I L 1150 6900 50
+F3 "MODE" I L 1150 7000 50
+F4 "BATT+" I L 1150 7100 50
 $EndSheet
 Wire Wire Line
-	700  7100 1200 7100
-Text Label 700  7100 0    50   ~ 0
+	650  7000 1150 7000
+Text Label 650  7000 0    50   ~ 0
 MODESEL
 Wire Wire Line
-	700  7000 1200 7000
-Text Label 700  7000 0    50   ~ 0
+	650  6900 1150 6900
+Text Label 650  6900 0    50   ~ 0
 READY
 Text Label 6600 3600 0    50   ~ 0
@@
 L Frequently_Used_LE:DGND #PWR017
 U 1 1 5F267B9F
-P 4500 4100
-F 0 "#PWR017" H 4500 3850 50  0001 C CNN
-F 1 "DGND" H 4505 3927 50  0000 C CNN
-F 2 "" H 4500 4100 50  0001 C CNN
-F 3 "" H 4500 4100 50  0001 C CNN
-	1    4500 4100
+P 4500 4150
+F 0 "#PWR017" H 4500 3900 50  0001 C CNN
+F 1 "DGND" H 4505 3977 50  0000 C CNN
+F 2 "" H 4500 4150 50  0001 C CNN
+F 3 "" H 4500 4150 50  0001 C CNN
+	1    4500 4150
 	1    0    0    -1
 $EndComp
@@
 Text Label 3350 3350 2    50   ~ 0
 XTAL1
-Text Label 4750 3550 0    50   ~ 0
+Text Label 4750 3350 0    50   ~ 0
 XTAL2
 Text Label 4750 3250 0    50   ~ 0
 XTAL1
+Wire Wire Line
+	650  7100 1150 7100
+Text Label 650  7100 0    50   ~ 0
+BATTSENS
+NoConn ~ 7050 1800
+NoConn ~ 7050 2300
+NoConn ~ 7050 2400
+NoConn ~ 7050 2500
+NoConn ~ 7050 2600
+Wire Wire Line
+	5250 3750 5150 3750
+Wire Wire Line
+	5150 3750 5150 3850
+Connection ~ 5150 4050
+Wire Wire Line
+	5150 4050 4500 4050
+Wire Wire Line
+	5250 3950 5150 3950
+Connection ~ 5150 3950
+Wire Wire Line
+	5150 3950 5150 4050
+Wire Wire Line
+	5250 3850 5150 3850
+Connection ~ 5150 3850
+Wire Wire Line
+	5150 3850 5150 3950
+Wire Wire Line
+	5250 1500 4500 1500
+Wire Wire Line
+	5250 1400 4500 1400
+Wire Wire Line
+	4500 1500 4500 1400
+Connection ~ 4500 1200
+Connection ~ 4500 1400
+Wire Wire Line
+	4500 1400 4500 1200
 $EndSCHEMATC

Commit message: Added level shifter, moved user interface connector location
Added level shifter, moved user interface connector location
Parts:
- added FID1: TOP1, Fiducial:Fiducial_1mm_Mask2mm, symbol Mechanical:Fiducial
- added FID2: TOP2, Fiducial:Fiducial_1mm_Mask2mm, symbol Mechanical:Fiducial
- added FID3: TOP3, Fiducial:Fiducial_1mm_Mask2mm, symbol Mechanical:Fiducial
- added FID4: BOT1, Fiducial:Fiducial_1mm_Mask2mm, symbol Mechanical:Fiducial
- added FID5: BOT2, Fiducial:Fiducial_1mm_Mask2mm, symbol Mechanical:Fiducial
- added FID6: BOT3, Fiducial:Fiducial_1mm_Mask2mm, symbol Mechanical:Fiducial
- C2, C3: Description (none) -> 18pF ±5% 50V Ceramic Capacitor C0G, NP0 0603 (1608 Metric)
- R1, R4, R9: footprint Frequently_Used_LE:0805_2012Metric_HandSolder -> Frequently_Used_LE:0805_2012Metric
- U1: Digikey Part No. ATMEGA32U4-AU-ND -> (none)
Connections:
- net labels added: AUDIORESET, AUDIORESET3V, BATT+, BATT-, SNDLATCH3V, SNDON3V, SNDRANDOM3V, SWITCH
- net labels removed: AUDRESET, BATTSENS
- wire segments 111 -> 124
- no-connect marks 7 -> 8
Other:
- note added: "Audio Chip and Amp"
- note added: "Lights and Audio Out"
- note removed: "Audio"
- note removed: "Lights"

Commit message: PCB Update
Other:
- note added: "Audio and Visual Out"
- note removed: "Lights and Audio Out"
Changed lines of the file:
@@
 ATmega34U4
 Text Notes 650  7700 0    79   ~ 16
-Lights and Audio Out
+Audio and Visual Out
 Wire Wire Line
 	6550 1300 7050 1300

Commit message: Switched to 0603_1608M size for passives
Parts:
- C1, C4, C5, C6: value 1.0uF -> 1uF; footprint Frequently_Used_LE:0805_2012Metric_HandSolder -> Frequently_Used_LE:0603_1608Metric; Description 1µF ±10% 16V Ceramic Capacitor X7R 0805 (2012 Metric) -> 1µF ±10% 10V Ceramic Capacitor X5R 0603 (1608 Metric); Manufacturer Part No. CL21B105KOFNNWE -> CL10A105KP8NNNC; Source Part No. 1276-2931-1-ND -> 1276-1182-1-ND
- C2, C3: footprint Frequently_Used_LE:0805_2012Metric_HandSolder -> Frequently_Used_LE:0603_1608Metric; Description 18pF ±5% 50V Ceramic Capacitor C0G, NP0 0603 (1608 Metric) -> 18pF ±10% 16V Ceramic Capacitor X8R 0603 (1608 Metric); Manufacturer Part No. C0603C180J5GACTU -> C0603C180K4HAC7867; Source Part No. 399-1052-1-ND -> 399-C0603C180K4HAC7867CT-ND
- C7: footprint Frequently_Used_LE:0805_2012Metric_HandSolder -> Frequently_Used_LE:0603_1608Metric; Description (none) -> 0.1µF -20%, +80% 16V Ceramic Capacitor Y5V (F) 0603 (1608 M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; Manufacturer Name (none) -> Samsung Electro-Mechanics; Manufacturer Part No. (none) -> CL10F104ZO8NNNC; Source (none) -> Digikey; Source Part No. (none) -> 1276-1258-1-ND
- D23, D24: footprint Frequently_Used_LE:LED_0805_2012Metric_HandSolder -> Frequently_Used_LE:LED_0805_2012Metric
- FID1: value TOP1 -> Fiducial; symbol Mechanical:Fiducial -> Mechanical_LE:Fiducial; Description (none) -> Fiducial mark; Manufacturer Name (none) -> None; Manufacturer Part No. (none) -> None; Name (none) -> TOP1; Source (none) -> None; Source Part No. (none) -> None
- FID2: value TOP2 -> Fiducial; symbol Mechanical:Fiducial -> Mechanical_LE:Fiducial; Description (none) -> Fiducial mark; Manufacturer Name (none) -> None; Manufacturer Part No. (none) -> None; Name (none) -> TOP2; Source (none) -> None; Source Part No. (none) -> None
- FID3: value TOP3 -> Fiducial; symbol Mechanical:Fiducial -> Mechanical_LE:Fiducial; Description (none) -> Fiducial mark; Manufacturer Name (none) -> None; Manufacturer Part No. (none) -> None; Name (none) -> TOP3; Source (none) -> None; Source Part No. (none) -> None
- FID4: value BOT1 -> Fiducial; symbol Mechanical:Fiducial -> Mechanical_LE:Fiducial; Description (none) -> Fiducial mark; Manufacturer Name (none) -> None; Manufacturer Part No. (none) -> None; Name (none) -> BOT1; Source (none) -> None; Source Part No. (none) -> None
- FID5: value BOT2 -> Fiducial; symbol Mechanical:Fiducial -> Mechanical_LE:Fiducial; Description (none) -> Fiducial mark; Manufacturer Name (none) -> None; Manufacturer Part No. (none) -> None; Name (none) -> BOT2; Source (none) -> None; Source Part No. (none) -> None
- FID6: value BOT3 -> Fiducial; symbol Mechanical:Fiducial -> Mechanical_LE:Fiducial; Description (none) -> Fiducial mark; Manufacturer Name (none) -> None; Manufacturer Part No. (none) -> None; Name (none) -> BOT3; Source (none) -> None; Source Part No. (none) -> None
- R1: footprint Frequently_Used_LE:0805_2012Metric -> Frequently_Used_LE:0603_1608Metric; Description 10 kOhms ±1% 0.25W, 1/4W Chip Resistor 0805 (2012 Metric) -> 10 kOhms ±1% 0.25W, 1/4W Chip Resistor 0603 (1608 Metric) A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; Manufacturer Name KOA Speer Electronics, Inc. -> Rohm Semiconductor; Manufacturer Part No. RK73H2ATTD1002F -> ESR03EZPF1002; Source Part No. 2019-RK73H2ATTD1002FCT-ND -> RHM10KADCT-ND
- R4, R9: footprint Frequently_Used_LE:0805_2012Metric -> Frequently_Used_LE:0603_1608Metric; Description 1 kOhms ±1% 0.25W, 1/4W Chip Resistor 1206 (3216 Metric) -> 1 kOhms ±1% 0.25W, 1/4W Chip Resistor 0603 (1608 Metric) Au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; Manufacturer Name KOA Speer Electronics, Inc. -> Rohm Semiconductor; Manufacturer Part No. RK73H2ATTD1001F -> ESR03EZPF1001; Source Part No. 2019-RK73H2ATTD1001FCT-ND -> RHM1.00KADCT-ND
Connections:
- net labels added: VOLUME, WHITELT
- wire segments 124 -> 127

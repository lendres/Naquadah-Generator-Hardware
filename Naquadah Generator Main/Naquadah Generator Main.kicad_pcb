File: Naquadah Generator Main/Naquadah Generator Main.kicad_pcb (KiCad board)
At the start: 2 copper layers, 115.6 x 115.6 mm, 127 parts, among them J0 Conn_ISP_Prog, J1 State_Sensing_Conn, J2 State_Sensing_Conn, J3 Conn_01x02, J4 Conn_01x02, J5 Conn_01x02, J6 Conn_01x02, J7 Conn_01x02, J8 USB Solder Pads, P1 USB_C_Plug_USB2.0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

Commit message: Before updating to two switches
Parts:
- removed BT1: Battery_Cell, Connector_Wire:SolderWirePad_1x02_P3.81mm_Drill1mm
- removed C10, C16: 22uF, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder
- removed D26, D27: GREEN, Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder
- removed D28: RED, Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder
- removed R34, R35, R36: 1k, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder
- removed R37: 1.54k, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder
- removed R39: 69.8k, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder
- removed TH1: 10k, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder
- removed U7: MCP73833T, Li-ion 5A Boost 1A Charge Protect:MCP73833
- removed W1, W2, W3, W4: 2.5x5.0, Li-ion 5A Boost 1A Charge Protect:Pad_3.0-5.0_w_TH
- added J10: Power_Daughter_Conn, Naquadah_Generator:Mother_Board_Vert_4_Pin_JST_Conn, B.Cu at (113.4, 100.0)
- added J9: Power_Conn, Naquadah_Generator:Keystone-1042, B.Cu at (82.0, 104.2)
- added Q1: 30V 5A, Naquadah_Generator:SOT-23_Handsoldering, F.Cu at (80.1, 167.9)
- added R2: 1k, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder, F.Cu at (65.5, -46.6)
- added TP1: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (21.2, -15.6)
- added TP2: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (13.6, -12.6)
- added TP3: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (13.8, -3.37)
- added TP4: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (13.8, 0.72)
- added TP5: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (17.8, -3.37)
- added TP6: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (17.8, 0.72)
- R33: value 1k -> 100
- SW2: value SW_SPST -> MODE; footprint Connector_Wire:SolderWirePad_1x02_P3.81mm_Drill1mm -> Naquadah_Generator:PTS526SMG15SMTR2LFS_Hand_Solder
- moved SW2 200.6 mm to (184.7, 72.7)
- moved R33 44.3 mm to (79.2, 163.0)
- moved C19 22.5 mm to (87.9, 112.1), turned to 90 degrees
- moved D29 18.3 mm to (80.1, 119.4), turned to 270 degrees
- moved L1 12.2 mm to (86.1, 125.8), turned to 90 degrees
- moved C11 2.86 mm to (86.5, 139.0), turned to 270 degrees
Connections:
- R33 pad 1: /Power/PG -> Net-(Q1-Pad1)
- R33 pad 2: Net-(D26-Pad1) -> /Power/SWITCH
- SW2 pad 1: Net-(BT1-Pad1) -> GND
- SW2 pad 2: /Power/BATT+ -> GND
- U1 pad 19: (no net) -> /MODESEL

Commit message: Updates
Parts:
- removed D30: RED, Li-ion 5A Boost 1A Charge Protect:LED_0805_2012Metric_HandSolder
- removed J4, J5, J6, J7: Conn_01x02, Connector_Wire:SolderWirePad_1x02_P3.81mm_Drill1.2mm
- removed R42: 1k, Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder
- removed SW2: MODE, Naquadah_Generator:PTS526SMG15SMTR2LFS_Hand_Solder
- removed W7, W8: 2.5x5.0, Li-ion 5A Boost 1A Charge Protect:Pad_3.0-5.0_w_TH
- added D25: LED, LED_SMD:LED_1812_4532Metric, F.Cu at (104.9, 145.7)
- added D26: LED, LED_SMD:LED_1812_4532Metric, F.Cu at (146.9, 103.7)
- added D27: LED, LED_SMD:LED_1812_4532Metric, F.Cu at (62.9, 103.7)
- added R34: 330, Frequently_Used:0805_2012Metric_HandSolder, F.Cu at (114.5, 145.7)
- added R35: 330, Frequently_Used:0805_2012Metric_HandSolder, F.Cu at (146.9, 94.2)
- added R36: 330, Frequently_Used:0805_2012Metric_HandSolder, F.Cu at (62.9, 94.5)
- added TP10: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (1.30, 112.3)
- added TP11: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (1.30, 116.4)
- added TP7: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (-6.88, 116.4)
- added TP8: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (-2.79, 112.3)
- added TP9: TestPoint, Frequently_Used:Pad_2.5-2.5, F.Cu at (-2.79, 116.4)
- D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D3, D4, D5, D6, D7, D8, D9: footprint LED_THT:LED_D5.0mm -> LED_SMD:LED_1812_4532Metric
- J0: footprint Naquadah_Generator:PinHeader_2x03_P2.54mm_Vertical -> Arduino:Connector_ISP
- J10: value Power_Daughter_Conn -> Power Board Conn; footprint Naquadah_Generator:Mother_Board_Vert_4_Pin_JST_Conn -> Naquadah_Generator:Mother_Board_Vert_5_Pin_JST_Conn
- moved R2 233.4 mm to (57.6, 186.7), turned to 90 degrees
- moved U4 190.9 mm to (135.4, 190.1), turned to 270 degrees
- moved U2 171.7 mm to (135.4, 176.5), turned to 0 degrees
- moved TP1 131.0 mm to (-6.88, 112.3)
- moved TP2 124.8 mm to (-24.5, 106.3)
- moved TP4 124.8 mm to (-24.3, 119.6)
- moved TP6 124.8 mm to (-20.2, 119.6)
- moved TP3 124.8 mm to (-24.3, 115.5)
- moved TP5 124.8 mm to (-20.2, 115.5)
- moved C12 113.4 mm to (76.1, 67.3), turned to 180 degrees
- moved J3 109.6 mm to (108.0, 98.8)
- moved U8 102.1 mm to (77.5, 77.6), turned to 270 degrees
- moved C18 100.5 mm to (78.4, 83.9), turned to 180 degrees
- moved R40 96.6 mm to (78.4, 88.1), turned to 180 degrees
- moved D2 95.0 mm to (104.9, 61.7), turned to 0 degrees
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Connections:
- net Net-(Q1-Pad1) renamed /Power/SWGATE
- C18 pad 1: /Power/BOOSTVOUT -> +5V
- C19 pad 1: /Power/BOOSTVOUT -> +5V
- C9 pad 2: /Power/BATT- -> /Power/SWBATT-
- D2 pad 1: GND -> /Shift Registers/RDLT
- D29 pad 1: /Power/BOOSTVOUT -> +5V
- J10 pad 3: /Power/SWITCH -> /MODESEL
- J10 pad 4: (no net) -> /READY
- J9 pad 1: Net-(J9-Pad1) -> /Power/BATT-
- Q1 pad 2: Net-(J9-Pad1) -> /Power/BATT-
- Q1 pad 3: /Power/BATT- -> /Power/SWBATT-
- R2 pad 1: Net-(J9-Pad1) -> /Power/BATT-
- R3 pad 1: Net-(D2-Pad2) -> +5V
- R3 pad 2: /Shift Registers/IND -> Net-(D2-Pad2)
- R40 pad 1: /Power/BOOSTVOUT -> +5V
- TP1 pad 1: /Power/BATT+ -> /Power/SWBATT-
- TP2 pad 1: Net-(J9-Pad1) -> /Power/BATT-
- U1 pad 28: (no net) -> /READY
- U3 pad 1: /Shift Registers/IND -> (no net)
- U5 pad 6: /Power/BATT- -> /Power/SWBATT-
- U6 pad 1: /Power/BATT- -> /Power/SWBATT-
Routing:
- net /Shift Registers/BLUELT1: track 0.00 -> 373.7 mm, vias 0 -> 1
- net /Shift Registers/BLUELT2: track 0.00 -> 370.8 mm, vias 0 -> 1
- net /Shift Registers/BLUELT3: track 0.00 -> 366.9 mm, vias 0 -> 1
- net /Shift Registers/BLUELT4: track 0.00 -> 366.3 mm, vias 0 -> 1
- net /Shift Registers/BLUELT5: track 0.00 -> 359.2 mm, vias 0 -> 1
- net GND: track 0.00 -> 1.59 mm, vias 0 -> 1
- added copper zone on F.Cu, net +5V
- added copper zone on B.Cu, net GND
Other:
- net class Lights added: clearance 0.2, trace_width 0.3, via_dia 0.8, via_drill 0.4
- board text added: "57.5"

Commit message: Updates
Parts:
- J1, J2: footprint Naquadah_Generator:State_Sensing_Mother_Board_JST_Conn -> Naquadah_Generator:Mother_Board_Hor_4_Pin_JST_Conn
- TP1, TP2, TP3, TP4, TP5, TP6, TP9: moved to B.Cu
- moved TP4 157.5 mm to (133.1, 118.8), turned to 327.5 degrees
- moved TP3 155.1 mm to (130.6, 122.8), turned to 327.5 degrees
- moved TP5 149.0 mm to (124.0, 78.1), turned to 327.5 degrees
- moved TP6 147.0 mm to (120.0, 75.5), turned to 327.5 degrees
- moved TP2 107.7 mm to (76.1, 144.7)
- moved TP9 101.9 mm to (88.4, 70.9)
- moved TP1 87.6 mm to (76.1, 140.2)
- moved U6 55.9 mm to (94.1, 137.1), turned to 180 degrees
- moved Q1 52.3 mm to (90.5, 142.9), turned to 90 degrees
- moved R32 51.0 mm to (88.3, 132.1), turned to 90 degrees
- moved R2 48.8 mm to (86.9, 147.7), turned to 180 degrees
- moved U5 47.9 mm to (88.3, 137.1)
- moved R33 47.5 mm to (85.9, 143.7)
- moved C9 47.0 mm to (83.8, 137.1)
- moved R31 41.5 mm to (79.4, 136.2), turned to 180 degrees
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Connections:
- net Net-(U5-Pad1) renamed /Power/PG1
- net Net-(U5-Pad3) renamed /Power/PG2
- J10 pad 1: GND -> /Power/BATT-
Routing:
- net /Power/BATT+: track 0.00 -> 33.4 mm, vias 0 -> 6
- net /Power/SWITCH: track 0.00 -> 31.4 mm
- net GND: track 1.59 -> 30.8 mm, vias 1 -> 20
- net /Power/BATT-: track 0.00 -> 23.9 mm, vias 0 -> 6
- net +5V: track 0.00 -> 18.5 mm
- net /Power/FB: track 0.00 -> 14.8 mm
- net /Power/PG1: track 0.00 -> 11.1 mm, vias 0 -> 2
- net /Power/PG2: track 0.00 -> 8.46 mm, vias 0 -> 2
- net /Power/SS: track 0.00 -> 7.49 mm
- net /Power/COMP: track 0.00 -> 7.48 mm
- net /Power/PVDD: track 0.00 -> 7.39 mm
- net /Power/SWGATE: track 0.00 -> 6.67 mm
- net /Power/PVM: track 0.00 -> 4.96 mm
- net Net-(C13-Pad1): track 0.00 -> 3.99 mm
- net /Power/SWBATT-: track 0.00 -> 3.67 mm, vias 0 -> 6
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- added copper zone on B.Cu, net /Power/BATT+
- added copper zone on F.Cu, net /Power/BATT+
- added copper zone on B.Cu, net /Power/BATT-
- added copper zone on F.Cu, net /Power/BATT-
- added copper zone on B.Cu, net /Power/SW
- added copper zone on F.Cu, net /Power/SW
- added copper zone on B.Cu, net /Power/SWBATT-
- added copper zone on F.Cu, net /Power/SWBATT-
- added copper zone on F.Cu, net GND

Commit message: Updates
Parts:
- moved P1 168.5 mm to (27.4, 119.7)
- moved U1 100.4 mm to (117.4, 103.9), turned to 315 degrees
- moved R36 13.8 mm to (63.1, 94.9), turned to 180 degrees
- moved R35 13.8 mm to (146.9, 112.7), turned to 180 degrees
- moved R34 13.6 mm to (113.9, 145.9), turned to 90 degrees
- moved R3 13.3 mm to (113.6, 61.4), turned to 90 degrees
- moved J3 0.10 mm to (93.4, 105.1)
Routing:
- net GND: vias 20 -> 22

Commit message: Move libraries and added configuration path.
Moved Li-Ion library to common KiCad library.  Added variables to configuration paths to reference my KiCad libraries.  Moved all 3D components to my common library.
Parts:
- C1, C2, C3, C4, C5, C6, C7, C8, R1, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24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: footprint Frequently_Used:0805_2012Metric_HandSolder -> FrequentlyUsed:0805_2012Metric_HandSolder
- C11, C19: footprint Li-ion 5A Boost 1A Charge Protect:UCD1E471MNL1GS -> Li-ion:UCD1E471MNL1GS
- C12, C13, C14, C15, C17, C18, C9, R2, R31, R32, R33, R38, R40, R41: footprint Li-ion 5A Boost 1A Charge Protect:0805_2012Metric_HandSolder -> Li-ion:0805_2012Metric_HandSolder
- D23, D24: footprint Frequently_Used:LED_0805_2012Metric_HandSolder -> FrequentlyUsed:LED_0805_2012Metric_HandSolder
- D29: footprint Li-ion 5A Boost 1A Charge Protect:DO-214AC -> Li-ion:DO-214AC
- L1: footprint Li-ion 5A Boost 1A Charge Protect:L_MGV0605 -> Li-ion:L_MGV0605
- TP1, TP10, TP11, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9: footprint Frequently_Used:Pad_2.5-2.5 -> FrequentlyUsed:Pad_2.5-2.5
- U5: footprint Li-ion 5A Boost 1A Charge Protect:SOT-23-6 -> Li-ion:SOT-23-6
- U6: footprint Li-ion 5A Boost 1A Charge Protect:SOT65P280X95-8N -> Li-ion:SOT65P280X95-8N
- U8: footprint Li-ion 5A Boost 1A Charge Protect:PAM2423AECADJR -> Li-ion:PAM2423AECADJR
- moved U4 98.7 mm to (66.2, 119.7), turned to 180 degrees
- moved U2 81.5 mm to (79.0, 117.7), turned to 270 degrees
- moved J9 0.75 mm to (87.6, 103.7)
Connections:
- U2 pad 1: /Shift Registers/SRRDLT -> /Shift Registers/SRBLUELT1
- U2 pad 15: /Shift Registers/SRGRNLT -> /Shift Registers/SRRDLT
- U2 pad 2: /Shift Registers/SRWHTLT -> /Shift Registers/SRBLUELT2
- U2 pad 3: /Shift Registers/SRBLUELT1 -> /Shift Registers/SRBLUELT3
- U2 pad 4: /Shift Registers/SRBLUELT2 -> /Shift Registers/SRBLUELT4
- U2 pad 5: /Shift Registers/SRBLUELT3 -> /Shift Registers/SRBLUELT5
- U2 pad 6: /Shift Registers/SRBLUELT4 -> /Shift Registers/SRWHTLT
- U2 pad 7: /Shift Registers/SRBLUELT5 -> /Shift Registers/SRGRNLT
- U4 pad 1: /Shift Registers/SRGRNLT -> /Shift Registers/SRRDLT
- U4 pad 10: (no net) -> +5V
- U4 pad 11: /Shift Registers/BLUELT5 -> /Shift Registers/GRNLT
- U4 pad 12: /Shift Registers/BLUELT4 -> /Shift Registers/WHTLT
- U4 pad 13: /Shift Registers/BLUELT3 -> /Shift Registers/BLUELT5
- U4 pad 14: /Shift Registers/BLUELT2 -> /Shift Registers/BLUELT4
- U4 pad 15: /Shift Registers/BLUELT1 -> /Shift Registers/BLUELT3
- U4 pad 16: /Shift Registers/WHTLT -> /Shift Registers/BLUELT2
- U4 pad 17: /Shift Registers/RDLT -> /Shift Registers/BLUELT1
- U4 pad 18: /Shift Registers/GRNLT -> /Shift Registers/RDLT
- U4 pad 2: /Shift Registers/SRRDLT -> /Shift Registers/SRBLUELT1
- U4 pad 3: /Shift Registers/SRWHTLT -> /Shift Registers/SRBLUELT2
- U4 pad 4: /Shift Registers/SRBLUELT1 -> /Shift Registers/SRBLUELT3
- U4 pad 5: /Shift Registers/SRBLUELT2 -> /Shift Registers/SRBLUELT4
- U4 pad 6: /Shift Registers/SRBLUELT3 -> /Shift Registers/SRBLUELT5
- U4 pad 7: /Shift Registers/SRBLUELT4 -> /Shift Registers/SRWHTLT
- U4 pad 8: /Shift Registers/SRBLUELT5 -> /Shift Registers/SRGRNLT
Routing:
- net /Shift Registers/GRNLT: track 0.00 -> 210.0 mm, vias 0 -> 2
- net /Shift Registers/RDLT: track 0.00 -> 197.8 mm, vias 0 -> 3
- net /Shift Registers/BLUELT1: track 373.9 -> 395.1 mm, vias 1 -> 2
- net /Shift Registers/BLUELT2: track 371.0 -> 390.6 mm, vias 1 -> 2
- net /Shift Registers/BLUELT3: track 366.9 -> 385.1 mm, vias 1 -> 2
- net /Shift Registers/BLUELT4: track 366.3 -> 383.1 mm, vias 1 -> 2
- net /Shift Registers/BLUELT5: track 359.2 -> 374.5 mm, vias 1 -> 2
- net +5V: track 18.5 -> 12.0 mm
- net /Shift Registers/SRBLUELT1: track 12.3 -> 18.4 mm
- net /Shift Registers/SRGRNLT: track 14.7 -> 8.81 mm
- net /Shift Registers/SRBLUELT3: track 9.45 -> 14.3 mm
- net /Shift Registers/SRBLUELT2: track 10.8 -> 15.3 mm
- net /Shift Registers/SRBLUELT4: track 8.26 -> 11.9 mm
- net /Shift Registers/SRBLUELT5: track 7.60 -> 9.81 mm
- net /Shift Registers/SRWHTLT: track 13.9 -> 14.4 mm
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
Commit message: PCB Updates
Parts:
- moved TP1 3.16 mm to (73.0, 140.1)
- moved TP2 0.91 mm to (77.1, 144.7)
Routing:
- net GND: track 30.8 -> 35.0 mm, vias 22 -> 25
- net /Shift Registers/RDLT: track 197.8 -> 196.1 mm
- net /Shift Registers/GRNLT: track 210.0 -> 211.1 mm

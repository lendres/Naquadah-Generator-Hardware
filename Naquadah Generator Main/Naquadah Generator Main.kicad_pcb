# Repository lendres/Naquadah-Generator-Hardware

File README.md:

# Naquadah-Generator-Hardware
 Naquadah Generator hardware files.

## KiCad design Naquadah Generator Main/Naquadah Generator Main.kicad_pcb

Board: 2 copper layers, 115.6 x 115.6 mm, 213 parts (35 on the bottom side), 142 nets.

Parts:
C1, C4, C5, C6, C14, C20, C22, C23, C24, C28, C29: 1uF; 0603_1608Metric
C2, C3: 18pF; 0603_1608Metric
C7, C9, C21, C30: 0.1uF; 0603_1608Metric
C8, C36: 4.7uF; 0603_1608Metric
C10, C16, C33: 22pF; 0603_1608Metric
C11, C19: 470uF; UCD1E471MNL1GS
C12, C18, C25, C34: 10uF; 0603_1608Metric
C13: 2.2nF; 0603_1608Metric
C15: 47pF; 0603_1608Metric
C17: 10nF; 0603_1608Metric
C26, C27: 220pF; 0603_1608Metric
C31: 470pF; 0603_1608Metric
C32: 10uF; T491A106K010AT
C35: 47nF; 0603_1608Metric
D1, D30: SDP; SOT-143
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D25, D26, D27: LED; LED_1812_4532Metric
D23: GREEN; LED_0805_2012Metric
D24, D28: YELLOW; LED_0805_2012Metric
D29, D31, D32: 5A 100V; DO-214AC
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4: PCB Mounting Hole; MountingHole_2.2mm_M2
H5, H6, H7, H8: Top Through Hole; MountingHole_Top_Conn_M6
J0: Conn_ISP_Prog; Connector_ISP
J1, J2: State_Sensing_Conn; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J3: Conn_01x02; JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical
J4, J8: USB Solder Pads; WireSoldPads_1x4_WOL
J5, J6: Conn_01x07; Header_1x07_P2.54mm_Surface
J7: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J9: Power_Conn; Keystone-1042
J10: User_Interface_6_Pin_Conn; JST_SH_BM06B-SRSS-TB_1x06-1MP_P1.00mm_Vertical
JP1, JP3, JP5, JP7: Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP4, JP6: Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 6.8uH; L_MGV0605
L2, L3, L4, L5: Ferrite; 0603_1608Metric
P1, P2: USB_C_Plug_USB2.0; 2047110001
Q1: 30V 5A; SOT-23_Handsoldering
R1, R41, R60: 10k; 0603_1608Metric
R2, R4, R9: 1k; 0603_1608Metric
R3, R5, R6, R7, R8, R10, R11, R12, R13, R15, R16, R17, R18, R20, R21, R22, R23, R25, R26, R27, R28, R31, R34, R35, R36: 330; 0603_1608Metric
R14, R37, R47, R48: 1M; 0603_1608Metric
R19, R24, R29, R30, R49, R50, R51, R52: 5.1k; 0603_1608Metric
R32: 2.7k; 0603_1608Metric
R33, R58, R59: 100; 0603_1608Metric
R38: 51k; 0603_1608Metric
R39, R42, R43, R44, R45, R46, R53, R54, R55, R56, R57, R61, R64, R65, R66, R67, R68, R69: 100k; 0603_1608Metric
R40: 30k; 0603_1608Metric
R62: 470; 0603_1608Metric
R63: 10; 0603_1608Metric
SW1: RESET; PTS526SMG15SMTR2LFS_Hand_Solder
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP15, TP16, TP17, TP18, TP19, TP20: TestPoint; Pad_2.5-2.5
TP14: Test Point; Pad_2.5-2.5
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
U2, U3: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm_Hand_Solder
U4: ULN2803ADWRG4; SOIC127P1030X265-18N
U5: AP9101CK6; SOT-23-6
U6: ECH8695R-TL-W; SOT65P280X95-8N
U7: VS1000; LQFP-48_7x7mm_P0.5mm
U8: PAM2421AECADJR; PAM2423AECADJR
U9: MX25L1606EM1I-12G; SOP-8_3.9x4.9mm_P1.27mm
U10: PAM8302AAD; SOP-8_3.9x4.9mm_P1.27mm
U11: MIC5219-3.3YM5-TR; SOT-23-5
U12: CD74HC4050PWR; TSSOP-16_4.4x5mm_P0.65mm
WA1: WireAssembly; Wire_Assembly
Y1: 16MHz; Oscillator_ABM3-16.000MHZ-B2-T
Y2: 12MHz; Oscillator_ABM3-16.000MHZ-B2-T

Connections:
+3V3: C32.1, JP1.1, JP5.1, JP7.1, L2.2, R53.2, R54.1, R56.2, TP14.1, TP18.1, U9.3, U9.7, U9.8, U11.5, U12.1
+5V: C6.1, C7.1, C18.1, C19.1, C29.1, C30.1, D23.1, D24.1, D29.1, D32.1, J0.2, J1.2, J2.2, J3.2, JP4.1, R1.1, R3.1, R5.1, R6.1, R7.1, R8.1, R10.1, R11.1, R12.1, R13.1, R15.1, R16.1, R17.1, R18.1, R20.1, R21.1, R22.1, R23.1, R25.1, R26.1, R27.1, R28.1, R34.1, R35.1, R36.1, R40.1, U1.14, U1.24, U1.34, U1.44, U2.10, U2.16, U3.10, U3.16, U4.10, U7.33, U11.1, U11.3
/AREF: C4.1, U1.42
/AUDIORESET3V: C22.1, R54.2, U7.1, U12.2
/Audio/AO+: C27.1, L5.1
/Audio/AO-: C26.1, L4.1
/Audio/AUDIOLEFT: R62.1, U7.47
/Audio/Audio USB/CC1: P2.A5, R50.2
/Audio/Audio USB/CC2: P2.B5, R49.2
/Audio/Audio USB/SHLD: C36.1, P2.S1, P2.S2, P2.S3, P2.S4, P2.S5, P2.S6, R48.1
/Audio/CBUF: R63.1, U7.43
/Audio/CS: R56.1, U7.22, U9.1
/Audio/CVDD: C20.1, C21.1, R47.1, U7.32
/Audio/D+: D30.2, J4.3, P2.A6, P2.B6, R51.1, R51.2, U7.35
/Audio/D-: D30.3, J4.2, P2.A7, P2.B7, R52.1, R52.2, U7.36
/Audio/GPIO_11: J6.6, R68.1, U7.20
/Audio/GPIO_12: J6.4, R66.1, U7.16
/Audio/GPIO_13: J6.5, R67.1, U7.17
/Audio/GPIO_14: J6.7, R69.1, U7.21
/Audio/IO_0: J5.1, R39.1, U7.2
/Audio/IO_1: J5.2, R42.1, U7.3
/Audio/IO_2: J5.3, R43.1, U7.4
/Audio/IO_3: J5.4, R44.1, U7.5
/Audio/IO_4: J5.5, R45.1, U7.9
/Audio/IO_5: D28.2, J5.6, U7.10
/Audio/IO_6: J5.7, R46.1, U7.11
/Audio/IO_7: R53.1, U7.12
/Audio/MISO: TP15.1, U7.25, U9.2
/Audio/MOSI: TP16.1, U7.24, U9.5
/Audio/Mono Amplifier PAM8302A/IN+: R58.1, U10.3
/Audio/Mono Amplifier PAM8302A/IN-: R59.1, U10.4
/Audio/Mono Amplifier PAM8302A/OUT+: L5.2, U10.5
/Audio/Mono Amplifier PAM8302A/OUT-: L4.2, U10.8
/Audio/Mono Amplifier PAM8302A/~SD: R60.1, U10.1
/Audio/POWBTN: C29.2, J7.1, R61.1, U7.37
/Audio/RCAP: C28.1, U7.45
/Audio/SCLK: TP17.1, U7.23, U9.6
/Audio/XTALI: C10.1, R37.1, U7.28, Y2.1
/Audio/XTALO: C16.1, R37.2, U7.29, Y2.2
/BATT+: C11.1, C12.1, C14.1, J9.2, J10.2, L1.1, R31.2, TP9.1, U1.37, U8.2, U8.3
/BATT-: J9.1, J10.1, Q1.2, R2.1, TP2.1
/Connectors/ATMeta USB/CC1: P1.A5, R24.2
/Connectors/ATMeta USB/CC2: P1.B5, R19.2
/Connectors/ATMeta USB/SHLD: C8.1, P1.S1, P1.S2, P1.S3, P1.S4, P1.S5, P1.S6, R14.1
/D+: D1.2, J8.3, P1.A6, P1.B6, R29.1, R29.2, U1.4
/D-: D1.3, J8.2, P1.A7, P1.B7, R30.1, R30.2, U1.3
/HALLEFF1: J1.3, TP3.1, U1.41
/HALLEFF2: J1.4, TP4.1, U1.40
/HALLEFF3: J2.4, TP6.1, U1.38
/HALLEFF4: J2.3, TP5.1, U1.39
/MISO: J0.1, U1.11
/MODESEL: J10.4, TP10.1, U1.29
/MOSI: J0.4, U1.10
/M_RX_A_TX: J7.3, U1.32, U7.26
/M_TX_A_RX: J7.2, U1.31, U7.27
/Power/Boost 3.0A 5V 0805_2012/COMP: C15.1, R38.1, U8.4
/Power/Boost 3.0A 5V 0805_2012/FB: R40.2, R41.1, U8.6
/Power/Boost 3.0A 5V 0805_2012/SS: C17.1, U8.7
/Power/Boost 3.0A 5V 0805_2012/SW: D29.2, L1.2, U8.8
/Power/Protection/PG1: U5.1, U6.2
/Power/Protection/PG2: U5.3, U6.4
/Power/Protection/PVDD: C9.1, R31.1, U5.5
/Power/Protection/PVM: R32.1, U5.2
/Power/SWBATT-: C9.2, Q1.3, TP1.1, U5.6, U6.1
/Power/SWGATE: Q1.1, R2.2, R33.1
/READY: J10.5, TP8.1, U3.15
/RXLED: R9.2, U1.8
/SCK: J0.3, U1.9
/SNDLATCH3V: J6.2, R64.1, U7.14, U12.4
/SNDON3V: J6.1, R55.1, U7.13, U12.6
/SNDRANDOM3V: J6.3, R65.1, U7.15, U12.10
/SRCLK: U1.27, U2.11, U3.11
/SRDATA: U1.25, U2.14
/SRLATCH: U1.26, U2.12, U3.12
/SWITCH: J10.6, R33.2, TP7.1
/Shift Registers/AUDIORESET5V: U3.1, U12.3
/Shift Registers/BLUELT1: D19.1, D20.1, D21.1, D22.1, U4.17
/Shift Registers/BLUELT2: D3.1, D4.1, D5.1, D6.1, U4.16
/Shift Registers/BLUELT3: D7.1, D8.1, D9.1, D10.1, U4.15
/Shift Registers/BLUELT4: D11.1, D12.1, D13.1, D14.1, U4.14
/Shift Registers/BLUELT5: D15.1, D16.1, D17.1, D18.1, U4.13
/Shift Registers/GRNLT: D26.1, D27.1, U4.11
/Shift Registers/RDLT: D2.1, D25.1, U4.18
/Shift Registers/SNDLATCH5V: U3.2, U12.5
/Shift Registers/SNDON5V: U3.3, U12.7
/Shift Registers/SNDRANDOM5V: U3.4, U12.9
/Shift Registers/SR1OUT2IN: U2.9, U3.14
/Shift Registers/SRBLUELT1: U2.7, U4.2
/Shift Registers/SRBLUELT2: U2.6, U4.3
/Shift Registers/SRBLUELT3: U2.5, U4.4
/Shift Registers/SRBLUELT4: U2.4, U4.5
/Shift Registers/SRBLUELT5: U2.3, U4.6
/Shift Registers/SRGRNLT: U2.1, U4.8
/Shift Registers/SRRDLT: U2.15, U4.1
/Shift Registers/SRWHTLT: U2.2, U4.7
/TXLED: R4.2, U1.22
/UCAP: C5.1, U1.6
/VOLUME: J10.3, TP20.1
/WHITELT: J3.1, U4.12
/XTAL1: C2.1, U1.17, Y1.1
/XTAL2: C3.1, U1.16, Y1.2
/nRESET: J0.5, R1.2, SW1.3, SW1.4, U1.13
AGND: C24.2, C25.1, C26.2, C27.2, C33.2, C35.2, JP3.1, L3.2, TP12.1, U7.38, U7.41, U7.42, U7.48, U10.7
AVDD: C25.2, JP7.2, L2.1, R60.2, TP19.1, U7.7, U7.19, U7.30, U7.34, U7.39, U7.44, U7.46, U10.6
DGND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C28.2, C30.2, C31.2, C32.2, C36.2, D1.1, D30.1, J0.6, J1.1, J2.1, J4.1, J7.4, J8.1, JP2.2, JP3.2, JP6.2, L3.1, P1.A1, P1.A12, P1.B1, P1.B12, P2.A1, P2.A12, P2.B1, P2.B12, R14.2, R19.1, R24.1, R32.2, R41.2, R47.2, R48.2, R49.1, R50.1, R61.2, SW1.1, SW1.2, TP11.1, TP13.1, U1.5, U1.15, U1.23, U1.33, U1.35, U1.43, U2.8, U2.13, U3.8, U3.13, U4.9, U6.3, U7.6, U7.8, U7.18, U7.31, U8.1, U8.5, U8.9, U9.4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
unnamed: C13.1, R38.2
unnamed: C23.1, R58.2
unnamed: C24.1, R59.2
unnamed: C31.1, U11.4
unnamed: C33.1, C34.2, R62.2
unnamed: C35.1, R63.2
unnamed: D2.2, R3.2
unnamed: D3.2, R5.2
unnamed: D4.2, R6.2
unnamed: D5.2, R7.2
unnamed: D6.2, R8.2
unnamed: D7.2, R10.2
unnamed: D8.2, R11.2
unnamed: D9.2, R12.2
unnamed: D10.2, R13.2
unnamed: D11.2, R15.2
unnamed: D12.2, R16.2
unnamed: D13.2, R17.2
unnamed: D14.2, R18.2
unnamed: D15.2, R20.2
unnamed: D16.2, R21.2
unnamed: D17.2, R22.2
unnamed: D18.2, R23.2
unnamed: D19.2, R25.2
unnamed: D20.2, R26.2
unnamed: D21.2, R27.2
unnamed: D22.2, R28.2
unnamed: D23.2, R4.1
unnamed: D24.2, R9.1
unnamed: D25.2, R34.2
unnamed: D26.2, R35.2
unnamed: D27.2, R36.2
unnamed: D28.1, R57.1
unnamed: D31.1, JP4.2
unnamed: JP1.2, JP2.1, R39.2, R42.2, R43.2, R44.2, R45.2, R46.2, R57.2
unnamed: JP5.2, JP6.1, R55.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2
VBUS: C1.1, D1.4, D30.4, D31.2, D32.2, J4.4, J8.4, P1.A4, P1.A9, P1.B4, P1.B9, P2.A4, P2.A9, P2.B4, P2.B9, U1.2, U1.7

## KiCad design User Interface Daughter Board/User Interface Daughter Board.kicad_pcb

Parts:
D1: GREEN; LED_0805_2012Metric; Manufacturer Part No. 150080VS75000
D5: RED; LED_0805_2012Metric; Manufacturer Part No. 150080RS75000
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm; Manufacturer Part No. None
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_2.7mm_M2.5; Manufacturer Part No. None
J1: Mother Board Conn; JST_SH_BM06B-SRSS-TB_1x06-1MP_P1.00mm_Vertical; Manufacturer Part No. BM04B-SRSS-TB(LF)(SN)
J2: Jack-DC; PJ-006A-SMT; Manufacturer Part No. PJ-006A-SMT-TR
R1, R5: 1k; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD1001F
R9, R10, R11, R12: 2.7k; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD2701F
SW1: SW_Push_DPDT_2-5_3-4_1-4; ESB-33535A; Manufacturer Part No. ESB-33535A
SW2, SW3, SW4: SW_Push_Dual_1-3_2-4; PTS647SK38SMTR2LFS; Manufacturer Part No. PTS 647 SN70 SMTR2 LFS
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; Pad_2.5-2.5; Manufacturer Part No. None
WA1: WireAssembly; Wire_Assembly; Manufacturer Part No. A06SR06SR30K305A

Connections:
/BATT+: J1.2 (BATT+), SW1.2 (C), SW1.5 (C), TP3.1; also elsewhere on the board
/MODE: J1.4 (MODE), SW2.2, SW2.4, TP2.1
/ONIND: D1.2 (A(P)), R1.2
/PWRIN: J2.1; also elsewhere on the board
/RDYIND: D5.2 (A(P)), R5.2
/READY: J1.5 (READY), R5.1, R12.1, TP1.1
/SWITCH: J1.6 (SWITCH), R1.1, SW1.1 (NO), SW1.4 (NO), TP5.1
/VOLUME: J1.3 (VOLUME), R10.1, R11.2, SW3.2, SW3.4, SW4.1, SW4.3, TP6.1
DGND: D1.1 (K(N)), D5.1 (K(N)), J1.1 (BATT-), J2.2, R9.2, SW2.1, SW2.3, TP4.1; also elsewhere on the board
unnamed: R9.1, R10.2, SW3.1, SW3.3
unnamed: R11.1, R12.2, SW4.2, SW4.4

Notes on the sheet:
Charging Connector
Neg 5.5mm sleeve Pos 2.1mm pin
Mother Board Connector
On/Off Switch
Power Indicator
Ready Indicator
Additional Features
Mode Button
Charge
Volume Down / Up
6 pin at 1 mm spacing cable assembly. The cable is reversed. The mother board and daughter board use the same foot prints.

Parts:
C1, C2: 22uF; 0805_2012Metric; Manufacturer Part No. CL21A226KQCLRNC
D2, D3: GREEN; LED_0805_2012Metric; Manufacturer Part No. 150080VS75000
D4: RED; LED_0805_2012Metric; Manufacturer Part No. 150080RS75000
R2, R3, R4: 1k; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD1001F
R6: 1.54k; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD1541F
R7: 69.8k; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD6982F
R8: 1.33k; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD1331F
TH1: 10k; 0805_2012Metric; Manufacturer Part No. NTCG203NH103JT1
U1: MCP73833T; MCP73833; Manufacturer Part No. MCP73833T-AMI/UN

Connections:
/BATT+: C2.1, U1.9 (VBAT), U1.10 (VBAT); also elsewhere on the board
/Charge 750mA/PG: R2.1, U1.7 (~PG/TE)
/Charge 750mA/PROG: R8.1, U1.6 (PROG)
/Charge 750mA/ST1: R4.1, U1.3 (STAT1)
/Charge 750mA/ST2: R3.1, U1.4 (STAT2)
/Charge 750mA/THRM: R6.1, R7.1, TH1.1
/Charge 750mA/THRMIC: R6.2, U1.8 (THERM)
/PWRIN: C1.1, D2.2 (A(P)), D3.2 (A(P)), D4.2 (A(P)), U1.1 (VDD), U1.2 (VDD); also elsewhere on the board
DGND: C1.2, C2.2, R7.2, R8.2, TH1.2, U1.5 (VSS); also elsewhere on the board
unnamed: D2.1 (K(N)), R2.2
unnamed: D3.1 (K(N)), R3.2
unnamed: D4.1 (K(N)), R4.2

Notes on the sheet:
750 mA Charge
Charge Current: 1A Maximum Constant current/constant voltage charging Ireg = 1000V / Rprog Where: Rprog is in kilo-ohms Ireg is in milliampere Rprog Ireg 1.0k 1000 mA 1.33k 750 mA 2.0k 500 ma 10k 100 mA
Rprog
P12 ooo Shutdown *oo Standby *oo Fault **o Charging *o* Charging complete *** Test

Board: 2 copper layers, 34.8 x 39.1 mm, 43 parts (7 on the bottom side), 20 nets.

## KiCad design State Sensing Board/State Sensing Board.kicad_pcb

Parts:
C1, C2: 47nF; 0805_2012Metric_HandSolder; Manufacturer Part No. CL21B473KBANNNC
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_0.5mm_Mask1mm; Manufacturer Part No. None
H1: MountingHole; MountingSlot_2.2mm_2.2mm_M2.0; Manufacturer Part No. None
J1: HallSensor_Conn; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; Manufacturer Part No. SM04B-SRSS-TB(LF)(SN)
R1, R29: 47K; 0805_2012Metric_HandSolder; Manufacturer Part No. RK73H2ATTD4702F
TP101, TP102, TP103, TP104: TestPoint_1; Pad_1.25-1.25; Manufacturer Part No. None
U1, U2: AH1815-P; SC-59_Hall_Sensor_Handsoldering; Manufacturer Part No. AH1815-W-7
WA1: WireAssembly; Wire_Assembly; Manufacturer Part No. A04SR04SR30K152A

Connections:
+5V: C1.1, C2.1, J1.2 (VCC), R1.1, TP102.1, U1.1 (VDD), U2.1 (VDD); also elsewhere on the board
GND: C1.2, C2.2, J1.1 (GND), TP101.1, U1.2 (GND), U2.2 (GND)
SENS1: J1.3 (SENS1), R1.2, TP103.1, U1.3 (OUTPUT)
SENS2: J1.4 (SENS2), TP104.1, U2.3 (OUTPUT); also elsewhere on the board

Notes on the sheet:
Hall Sensor Schematic
Connectors
Additional Features
6 pin at 1 mm spacing cable assembly. The cable is reversed. The mother board and daughter board use the same foot prints.

Board: 2 copper layers, 29.7 x 7.5 mm, 19 parts (12 on the bottom side), 4 nets.

Other parts of the board:
R2: 47K; 0805_2012Metric_HandSolder

Their connections:
+5V: R2.1; also elsewhere on the board
SENS2: R2.2; also elsewhere on the board

## KiCad design Li-ion 5A Boost 1A Charge Protect/Li-ion 5A Boost 1A Charge Protect.kicad_pcb

Board: 2 copper layers, 58.0 x 39.0 mm, 44 parts (0 on the bottom side), 25 nets.

Parts:
+: 2.5x5.0; Pad_3.0-5.0_w_TH
+#2: 2.5x5.0; Pad_3.0-5.0_w_TH
-: 2.5x5.0; Pad_3.0-5.0_w_TH
-#2: 2.5x5.0; Pad_3.0-5.0_w_TH
B+: 2.5x5.0; Pad_3.0-5.0_w_TH
B-: 2.5x5.0; Pad_3.0-5.0_w_TH
C1: 100nF; 0805_2012Metric_HandSolder
C2, C8: 22uF; 0805_2012Metric_HandSolder
C3, C11: 470uF; UCD1E471MNL1GS
C4, C10: 10uF; 0805_2012Metric_HandSolder
C5: 2.2nF; 0805_2012Metric_HandSolder
C6: 1uF; 0805_2012Metric_HandSolder
C7: 47pF; 0805_2012Metric_HandSolder
C9: 10nF; 0805_2012Metric_HandSolder
D1: NTS12120EMFST1G
J1: USB_C_FEMALE; GCT_USB4110-GF-A
L1: 6.8uH; L_MGV1004
LD1, LD2: GREEN; LED_0805_2012Metric_HandSolder
LD3, LD4: RED; LED_0805_2012Metric_HandSolder
R1: 330; 0805_2012Metric_HandSolder
R2: 2.7k; 0805_2012Metric_HandSolder
R3, R4, R5, R6, R12: 1k; 0805_2012Metric_HandSolder
R7: 1.54k; 0805_2012Metric_HandSolder
R8: 69.8k; 0805_2012Metric_HandSolder
R9: 51k; 0805_2012Metric_HandSolder
R10: 30k; 0805_2012Metric_HandSolder
R11: 10k; 0805_2012Metric_HandSolder
SW1: SW_SPST; GF1230054
SWI: 2.5x5.0; Pad_3.0-5.0_w_TH
SWO: 2.5x5.0; Pad_3.0-5.0_w_TH
TH1: 10k; 0805_2012Metric_HandSolder
U1: AP9101CK6; SOT-23-6
U2: ECH8695R-TL-W; SOT65P280X95-8N
U3: MCP73833T; MCP73833
U4: PAM2423AECADJR

Connections:
/BATT+: B+.1, C8.1, R1.2, SW1.2, SWI.1, U3.9, U3.10
/BATT-: B-.1, C1.2, U1.6, U2.1
/BOOSTVIN: C3.1, C4.1, C6.1, L1.1, SW1.1, SWO.1, U4.2, U4.3
/BOOSTVOUT: +.1, C10.1, C11.1, D1.5, D1.5A, D1.5B, D1.5C, D1.5D, R10.1, R12.1
/COMP: C7.1, R9.1, U4.4
/FB: R10.2, R11.1, U4.6
/PG: R3.1, U3.7
/PROG: R6.1, U3.6
/PVDD: C1.1, R1.1, U1.5
/PVM: R2.1, U1.2
/SS: C9.1, U4.7
/ST1: R5.1, U3.3
/ST2: R4.1, U3.4
/SW: D1.1, D1.2, D1.3, L1.2, U4.8
/THRM: R7.1, R8.1, TH1.1
/THRMIC: R7.2, U3.8
/VUSB: +#2.1, C2.1, J1.A4/B9, J1.B4/A9, LD1.2, LD2.2, LD3.2, U3.1, U3.2
GND: -.1, -#2.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.A1/B12, J1.B1/A12, LD4.1, R2.2, R6.2, R8.2, R11.2, TH1.2, U2.3, U3.5, U4.1, U4.5, U4.9
unnamed: C5.1, R9.2
unnamed: LD1.1, R3.2
unnamed: LD2.1, R4.2
unnamed: LD3.1, R5.2
unnamed: LD4.2, R12.2
unnamed: U1.1, U2.2
unnamed: U1.3, U2.4

## Commit log

2020-04-26 Update hall sensor board.
2020-04-26 Update component values
2020-04-27 State sensing board revisions
    Moved everything except hall sensors to back of state sensing board.
2020-04-27 Updates to State Sensing Board
2020-05-09 Before changing BOM
2020-05-09 Updates before converting to 0805_2012
2020-05-10 Moved Li-Ion Libraries
2020-05-10 Start of PCB Layout
2020-05-10 Preliminary PCB layout 1
2020-05-11 Updates to PCB
2020-05-11 PCB Updates
2020-05-11 Updated diode footprint
2020-05-11 Updates to Boost out on PCB
2020-05-11 PCB Update
2020-05-12 PCB Update
    Working layout with repositioned charge and protect sections. Still work to be done on labeling, 3D models, and copper pours on bottom.
2020-05-12 PCB Before Solder Footprint Switch
    Before switching wire solder points to foot prints with through holes.
2020-05-12 PCB Update, back silk screen
2020-05-13 PCB and 3D model updates
2020-05-13 PCB Cleanup and corrections
2020-05-13 PCB Tweaks
2020-05-15 Version 1.0.0
    Version 1.0.0
2020-05-19 Changed name of libraries to remove underscore
2020-05-20 Partial Update
2020-05-26 Resize to correct for scale
2020-05-26 Size corrections and other PCB prep
2020-05-29 Updates to PCB Mount
2020-05-30 Library Updates
2020-05-31 Added real power schematic
2020-05-31 Symbol field corrections and additions
2020-06-06 Adding Power Daughter Board
2020-06-06 PCB preliminary version
2020-06-06 Changer power daughter board directory name
2020-06-07 Clean up
2020-06-08 Switched to 4 pin power board connector
2020-06-08 Before updating to two switches
2020-06-09 Power board 2 switch V1
2020-06-14 Move libraries and added configuration path.
    Moved Li-Ion library to common KiCad library. Added variables to configuration paths to reference my KiCad libraries. Moved all 3D components to my common library.
2020-08-01 Start of audio
2020-08-03 Separated digital and analog ground.
2020-08-15 Audio update
2020-08-20 Power updates
2020-08-20 Organization
2020-08-20 Fixed analog and digital power symbol names.
2020-08-22 Before switching buttons on daughter board
2020-08-24 Audio updates, switching to separate USB schematic
    Audio updates, switching to separate USB schematic
2020-08-26 Added level shifter, moved user interface connector location
    Added level shifter, moved user interface connector location
2020-08-29 Switched to 0603_1608M size for passives
2020-08-29 Removed schematic templates, Added audio connection
    Removed schematic templates, Added audio connection
2020-08-29 Rename daughter board to User Interface
2020-08-30 Update JST connectors
2020-09-03 Clean up of audio page
2020-10-01 Updated fiducials.
